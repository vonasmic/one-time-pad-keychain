# IAR project TrustZone_app_NS.ewp, settings and files
configuration TrustZone_app_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U535CB ST STM32U535CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U535xx
  ICCARM.CCIncludePath2: ../NonSecure/Core/Inc; ../Secure_nsclib; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZone_app_NS.hex
  ILINK.IlinkOutputFile: TrustZone_app_NS.out
  ILINK.IlinkIcfFile: stm32u535xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u535xx.s
  group Application/User/NonSecure/Core
    ../NonSecure/Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/CMSIS
    ../NonSecure/Core/Src/: system_stm32u5xx_ns.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c
